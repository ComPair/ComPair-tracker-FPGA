SRC_URI += "file://user_2020-02-20-18-50-00.cfg \
            file://user_2020-03-09-16-13-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

